Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Ostnor
Time: 2008-09-22T09:53:43
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: Mora Rexx 707155, 707155:Mora Rexx 707155:Mora Rexx 707155:130059
In: Level 1
PSet_Revit_Dimensions - Basin Height: 850 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 35
PSet_Revit_Type_Identity Data - VVS: 70 1990.104; URL: www.moraarmatur.com; RSK: 834 44 24; NRF: 429 08 36; Model: 707155; Manufacturer: Mora Armatur AB; LVI: 6160624; Family: Mora Rexx; Description: Mora Rexx B5 Basin Mixer with pop-up waste Chrome, also available as Chrome/Black and Stainless look
